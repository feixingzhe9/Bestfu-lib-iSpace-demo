# Keil uVision project Demo_L151.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BestFu_STM32L15X_L10200 (library)
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32L1XX_MD,STM32L151
  c include: ..\..\Lib_code\SysLib\inc;..\SysHard\inc;..\..\Lib_code\App;..\Project;..\Core
  memory RVCT4: ROM 0x8000800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Core
    ../Core/: system_stm32l1xx.c startup_stm32l1xx_md.s
  group BestFuLib
    ../../Lib_code/SysLib/: BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c Sign433.c Sign433Attr.c Encode_lib.lib AttrEncrypt .c DlyAttrProcess.c LinksimplestTime.c DeviceIDSetAttr.c DevPartTab.c TimeHandle.c
  group SysHard
    ../SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
  group User
    ../../Lib_code/App/: main.c UnitCfg.c
