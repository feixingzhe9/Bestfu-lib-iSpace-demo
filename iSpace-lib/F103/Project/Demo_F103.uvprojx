# Keil uVision project Demo_F103.uvprojx, settings and files
target Traget (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BestFu_STM32F10X_10200 (library)
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\Core;..\SysHard\inc;..\..\Lib_code\SysLib\inc;..\..\Lib_code\App;..\User\Signal_Act
  memory RVCT4: ROM 0x8000800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
  group BestFuLib
    ../../Lib_code/SysLib/: AttrEncrypt .c BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c LinksimplestTime.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c Encode_lib.lib DlyAttrProcess.c TimeHandle.c Linksimplest.c DeviceIDSetAttr.c DevPartTab.c Group.c
  group SysHard
    ../SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
    ../../Lib_code/App/: UnitCfg.c main.c
  group User
    ../User/Signal_Act/: SigActExeAttr.c SingleUnit.c SingleDrive.c
